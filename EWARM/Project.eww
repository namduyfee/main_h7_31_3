<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Main_RB_K14_CODE.ewp</path>
  </project>
  <batchBuild />
</workspace>
