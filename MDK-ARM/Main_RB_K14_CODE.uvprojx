# Keil uVision project Main_RB_K14_CODE.uvprojx, settings and files
target Main_RB_K14_CODE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Main_RB_K14_CODE +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../FEE;../Robot;..\LCD_1.69_lb;..\LCD_1.69_lb\GUI_DEV
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Core/Inc/: dwt_stm32_delay.c
  group FEE_Team_Code
    ../FEE/: FEE_ADC.c FEE_ADC.h FEE_RTOS.c FEE_RTOS.h FEE_USB.c FEE_USB.h FEE_EXTI.c FEE_EXTI.h FEE_PWM.c FEE_PWM.h FEE_LCD.c FEE_LCD.h FEE_SPI.c FEE_SPI.h FEE_UART.c FEE_UART.h FEE_GPIO.c FEE_GPIO.h FEE_PES_Control.c FEE_PES_control.h FEE_Compass.h FEE_Compass.c FEE_SWERVE_DRIVER.c FEE_SWERVE_DRIVER.h FEE_AT24C128.c FEE_AT24C128.h FEE_Kalman_Filter.c FEE_Kalman_Filter.h FEE_STM32F103C8T6.c FEE_STM32F103C8T6.h FEE_Absolute_Encoder.c FEE_Absolute_Encoder.h FEE_Library.h FEE_Main_Phu.c FEE_Main_Phu.h
  group Robot_Code
    ../Robot/: FEE_Robot.c FEE_Robot.h FEE_Thread1.c FEE_Thread2.c FEE_Thread3.c FEE_Thread4.c FEE_Thread5.c FEE_Thread6.c FEE_Thread7.c FEE_Thread8.c FEE_Thread9.c FEE_Thread10.c FEE_Thread11.c FEE_Thread12.c FEE_Thread13.c FEE_Thread14.c FEE_Thread15.c FEE_Tu_Dong.c FEE_Tu_Dong.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group LCD_1.69_lb
    ../LCD_1.69_lb/: DEV_Config.c LCD_1in69.c
    ../LCD_1.69_lb/GUI_DEV/: font8.c font12.c font16.c font20.c font24.c GUI_Paint.c image.c
software components: CMSIS:CORE 5.6.0
